v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/res_high_po_0p35.sym} 0 0 0 0 {name=R1
L=10
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/iopin.sym} -20 0 2 0 {name=p1 lab=VSUBS}
C {devices/iopin.sym} 0 -30 2 0 {name=p2 lab=A}
C {devices/iopin.sym} 0 30 2 0 {name=p3 lab=B}
